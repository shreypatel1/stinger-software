Commit message: ekf yaml modify

File: stinger_description/urdf/stinger_tug.urdf (robot description, URDF)
Before this commit: robot stinger_tug, 6 links, 5 joints
Joints:
- joint hull_joint: origin xyz=0 0 0 -> xyz=0 0 0 rpy=0 0 0
- joint imu_joint: origin xyz=0 0 0 -> xyz=0 0 0 rpy=0 0 0
